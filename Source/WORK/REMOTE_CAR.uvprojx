# Keil uVision project REMOTE_CAR.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103R4 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: REMOTE_CAR
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\HAL\LIB\inc;..\HAL\CMSIS;..\SYS;..\HAL;..\DEV\DevUart;..\SYS\SystemLib;..\MID
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group init
    ../HAL/CMSIS/: startup_stm32f10x_hd.s core_cm3.c
  group Lib
    ../HAL/LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group APP
    ../APP/Application/: Application.c
  group DEV
    ../DEV/DevI2C/: DevI2C.c
    ../DEV/DevUart/: DevUART.c
  group HAL
    ../HAL/: HalGpio.c HalUART.c IntHandler.c
  group SYS
    ../SYS/MainLoop/: sysmain.c
    ../SYS/SystemLib/: system_stm32f10x.c
  group MID
    ../MID/: MidLoraCom.c
